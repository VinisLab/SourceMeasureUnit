# IAR project stm32f746_disco_lvgl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32; STM32F7; STM32F746NGHx; STM32F746G_DISCO; DEBUG; STM32F746xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ../..; ../../CMSIS/Core; ../../CMSIS/device; ../../HAL_Driver/Inc; ../../Utilities/STM32746G-Discovery
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; STM32; STM32F7; STM32F746NGHx; STM32F746G_DISCO; DEBUG; STM32F746xx; USE_HAL_DRIVER
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: stm32f746_disco_lvgl.hex
  group HAL_Driver/Src
    ../../HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_timebase_rtc_alarm_template.c stm32f7xx_hal_timebase_rtc_wakeup_template.c stm32f7xx_hal_timebase_tim_template.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
  group hal_stm_lvgl/tft
    ../../hal_stm_lvgl/tft/: tft.c
  group hal_stm_lvgl/touchpad
    ../../hal_stm_lvgl/touchpad/: touchpad.c
  group lv_examples/assets
    ../../lv_examples/assets/: img_cogwheel_alpha16.c img_cogwheel_argb.c img_cogwheel_chroma_keyed.c img_cogwheel_indexed16.c img_cogwheel_rgb.c img_hand.c lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
  group lv_examples/src/lv_demo_benchmark
    ../../lv_examples/src/lv_demo_benchmark/: lv_demo_benchmark.c
  group lv_examples/src/lv_demo_keypad_encoder
    ../../lv_examples/src/lv_demo_keypad_encoder/: lv_demo_keypad_encoder.c
  group lv_examples/src/lv_demo_music
    ../../lv_examples/src/lv_demo_music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
  group lv_examples/src/lv_demo_music/assets
    ../../lv_examples/src/lv_demo_music/assets/: img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_4.c img_lv_demo_music_cover_5.c img_lv_demo_music_cover_bg.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_4.c img_lv_demo_music_list_border.c img_lv_demo_music_slider_knob.c img_lv_demo_music_wave_1.c img_lv_demo_music_wave_1_top.c img_lv_demo_music_wave_2.c img_lv_demo_music_wave_2_top.c img_lv_demo_music_wave_3.c lv_demo_music_font_16_bold.c
  group lv_examples/src/lv_demo_printer
    ../../lv_examples/src/lv_demo_printer/: lv_demo_printer.c lv_demo_printer_theme.c
  group lv_examples/src/lv_demo_printer/images
    ../../lv_examples/src/lv_demo_printer/images/: lv_demo_printer_icon_bright.c lv_demo_printer_icon_eco.c lv_demo_printer_icon_hue.c lv_demo_printer_icon_pc.c lv_demo_printer_icon_tel.c lv_demo_printer_icon_wifi.c lv_demo_printer_img_btn_bg_1.c lv_demo_printer_img_btn_bg_2.c lv_demo_printer_img_btn_bg_3.c lv_demo_printer_img_btn_bg_4.c lv_demo_printer_img_cloud.c lv_demo_printer_img_copy.c lv_demo_printer_img_internet.c lv_demo_printer_img_mobile.c lv_demo_printer_img_no_internet.c lv_demo_printer_img_phone.c lv_demo_printer_img_print.c lv_demo_printer_img_printer2.c lv_demo_printer_img_ready.c lv_demo_printer_img_scan.c lv_demo_printer_img_scan_example.c lv_demo_printer_img_setup.c lv_demo_printer_img_usb.c lv_demo_printer_img_wave.c
  group lv_examples/src/lv_demo_stress
    ../../lv_examples/src/lv_demo_stress/: lv_demo_stress.c
  group lv_examples/src/lv_demo_widgets
    ../../lv_examples/src/lv_demo_widgets/: lv_demo_widgets.c
  group lv_examples/src/lv_ex_get_started
    ../../lv_examples/src/lv_ex_get_started/: lv_ex_get_started_1.c lv_ex_get_started_2.c lv_ex_get_started_3.c
  group lv_examples/src/lv_ex_style
    ../../lv_examples/src/lv_ex_style/: lv_ex_style_1.c lv_ex_style_10.c lv_ex_style_11.c lv_ex_style_2.c lv_ex_style_3.c lv_ex_style_4.c lv_ex_style_5.c lv_ex_style_6.c lv_ex_style_7.c lv_ex_style_8.c lv_ex_style_9.c
  group lv_examples/src/lv_ex_widgets/lv_ex_arc
    ../../lv_examples/src/lv_ex_widgets/lv_ex_arc/: lv_ex_arc_1.c lv_ex_arc_2.c
  group lv_examples/src/lv_ex_widgets/lv_ex_bar
    ../../lv_examples/src/lv_ex_widgets/lv_ex_bar/: lv_ex_bar_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_btn
    ../../lv_examples/src/lv_ex_widgets/lv_ex_btn/: lv_ex_btn_1.c lv_ex_btn_2.c
  group lv_examples/src/lv_ex_widgets/lv_ex_btnmatrix
    ../../lv_examples/src/lv_ex_widgets/lv_ex_btnmatrix/: lv_ex_btnmatrix_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_calendar
    ../../lv_examples/src/lv_ex_widgets/lv_ex_calendar/: lv_ex_calendar_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_canvas
    ../../lv_examples/src/lv_ex_widgets/lv_ex_canvas/: lv_ex_canvas_1.c lv_ex_canvas_2.c
  group lv_examples/src/lv_ex_widgets/lv_ex_chart
    ../../lv_examples/src/lv_ex_widgets/lv_ex_chart/: lv_ex_chart_1.c lv_ex_chart_2.c
  group lv_examples/src/lv_ex_widgets/lv_ex_checkbox
    ../../lv_examples/src/lv_ex_widgets/lv_ex_checkbox/: lv_ex_checkbox_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_cont
    ../../lv_examples/src/lv_ex_widgets/lv_ex_cont/: lv_ex_cont_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_cpicker
    ../../lv_examples/src/lv_ex_widgets/lv_ex_cpicker/: lv_ex_cpicker_1.c lv_ex_cpicker_2.c
  group lv_examples/src/lv_ex_widgets/lv_ex_dropdown
    ../../lv_examples/src/lv_ex_widgets/lv_ex_dropdown/: lv_ex_dropdown_1.c lv_ex_dropdown_2.c
  group lv_examples/src/lv_ex_widgets/lv_ex_gauge
    ../../lv_examples/src/lv_ex_widgets/lv_ex_gauge/: lv_ex_gauge_1.c lv_ex_gauge_2.c
  group lv_examples/src/lv_ex_widgets/lv_ex_img
    ../../lv_examples/src/lv_ex_widgets/lv_ex_img/: lv_ex_img_1.c lv_ex_img_2.c lv_ex_img_3.c
  group lv_examples/src/lv_ex_widgets/lv_ex_imgbtn
    ../../lv_examples/src/lv_ex_widgets/lv_ex_imgbtn/: imgbtn_blue.c imgbtn_green.c lv_ex_imgbtn_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_keyboard
    ../../lv_examples/src/lv_ex_widgets/lv_ex_keyboard/: lv_ex_keyboard_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_label
    ../../lv_examples/src/lv_ex_widgets/lv_ex_label/: lv_ex_label_1.c lv_ex_label_2.c lv_ex_label_3.c
  group lv_examples/src/lv_ex_widgets/lv_ex_led
    ../../lv_examples/src/lv_ex_widgets/lv_ex_led/: lv_ex_led_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_line
    ../../lv_examples/src/lv_ex_widgets/lv_ex_line/: lv_ex_line_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_linemeter
    ../../lv_examples/src/lv_ex_widgets/lv_ex_linemeter/: lv_ex_linemeter_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_list
    ../../lv_examples/src/lv_ex_widgets/lv_ex_list/: lv_ex_list_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_msgbox
    ../../lv_examples/src/lv_ex_widgets/lv_ex_msgbox/: lv_ex_msgbox_1.c lv_ex_msgbox_2.c
  group lv_examples/src/lv_ex_widgets/lv_ex_obj
    ../../lv_examples/src/lv_ex_widgets/lv_ex_obj/: lv_ex_obj_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_objmask
    ../../lv_examples/src/lv_ex_widgets/lv_ex_objmask/: lv_ex_objmask_1.c lv_ex_objmask_2.c
  group lv_examples/src/lv_ex_widgets/lv_ex_page
    ../../lv_examples/src/lv_ex_widgets/lv_ex_page/: lv_ex_page_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_roller
    ../../lv_examples/src/lv_ex_widgets/lv_ex_roller/: lv_ex_roller_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_slider
    ../../lv_examples/src/lv_ex_widgets/lv_ex_slider/: lv_ex_slider_1.c lv_ex_slider_2.c
  group lv_examples/src/lv_ex_widgets/lv_ex_spinbox
    ../../lv_examples/src/lv_ex_widgets/lv_ex_spinbox/: lv_ex_spinbox_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_spinner
    ../../lv_examples/src/lv_ex_widgets/lv_ex_spinner/: lv_ex_spinner_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_switch
    ../../lv_examples/src/lv_ex_widgets/lv_ex_switch/: lv_ex_switch_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_table
    ../../lv_examples/src/lv_ex_widgets/lv_ex_table/: lv_ex_table_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_tabview
    ../../lv_examples/src/lv_ex_widgets/lv_ex_tabview/: lv_ex_tabview_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_textarea
    ../../lv_examples/src/lv_ex_widgets/lv_ex_textarea/: lv_ex_textarea_1.c lv_ex_textarea_2.c lv_ex_textarea_3.c
  group lv_examples/src/lv_ex_widgets/lv_ex_tileview
    ../../lv_examples/src/lv_ex_widgets/lv_ex_tileview/: lv_ex_tileview_1.c
  group lv_examples/src/lv_ex_widgets/lv_ex_win
    ../../lv_examples/src/lv_ex_widgets/lv_ex_win/: lv_ex_win_1.c
  group lvgl/src/lv_core
    ../../lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group lvgl/src/lv_draw
    ../../lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl/src/lv_font
    ../../lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c
  group lvgl/src/lv_gpu
    ../../lvgl/src/lv_gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
  group lvgl/src/lv_hal
    ../../lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/lv_misc
    ../../lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/lv_themes
    ../../lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
  group lvgl/src/lv_widgets
    ../../lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group src
    ../../src/: main.c stm32f7xx_it.c system_stm32f7xx.c
  group startup
    ./: startup_stm32f746xx.s
  group Utilities/Components/ft5336
    ../../Utilities/Components/ft5336/: ft5336.c
  group Utilities/STM32746G-Discovery
    ../../Utilities/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_audio.c stm32746g_discovery_camera.c stm32746g_discovery_eeprom.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
